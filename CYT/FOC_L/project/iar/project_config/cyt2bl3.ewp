# IAR project cyt2bl3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT2BL_M4 Infineon CYT2BL_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: tviibe4m; CYT2BL8CAE; CY_USE_PSVP=0; CY_MCU_rev_a; CPU_BOARD_REVC
  ICCARM.CCDiagSuppress: Pa082,Pa134
  ICCARM.CCIncludePath2: ..\..\..\libraries\sdk\common\hdr; ..\..\..\libraries\sdk\common\hdr\cmsis\include; ..\..\..\libraries\sdk\common\src\drivers; ..\..\..\libraries\sdk\common\src\mw; ..\..\..\libraries\sdk\tviibh4m\hdr; ..\..\..\libraries\sdk\tviibh4m\hdr\ip; ..\..\..\libraries\sdk\tviibh4m\hdr\mcureg; ..\..\..\libraries\sdk\tviibh4m\src; ..\..\..\libraries\sdk\tviibh4m\src\interrupts; ..\..\..\libraries\sdk\tviibh4m\src\mw; ..\..\..\libraries\sdk\tviibh4m\src\drivers; ..\..\..\libraries\sdk\tviibh4m\src\system; ..\..\..\libraries\sdk\common\hdr\cmsis\dsp; ..\..\..\libraries\zf_common; ..\..\..\libraries\zf_driver; ..\..\..\libraries\zf_device; ..\..\..\libraries\zf_components; ..\..\user; ..\..\code
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cyt2bl3.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: _CORE_cm4_=0; _LINK_flash_=0
  ILINK.IlinkIcfFile: ..\icf\linker_directives_tviibe4m.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\libraries\zf_device\zf_device_config.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group code
    ../../code/: FOC_TCPWM_ADC名词解释.md FOC_TCPWM触发ADC采样链路.md My_Headfile.h 本文件夹作用.txt
  group code/Current_sample
    ../../code/Current_sample/: Current_sample.c Current_sample.h
  group code/Fast_sin
    ../../code/Fast_sin/: Fast_sin.c Fast_sin.h
  group code/Filter
    ../../code/Filter/: AB_Filter.c AB_Filter.h Sliding_Filter.c Sliding_Filter.h
  group code/Foc_Protocol
    ../../code/Foc_Protocol/: Foc_Protocol.c Foc_Protocol.h
  group code/Foc_transform
    ../../code/Foc_transform/: Foc_transform.c Foc_transform.h
  group code/Foc_voice
    ../../code/Foc_voice/: Foc_voice.c Foc_voice.h
  group code/Function
    ../../code/Function/: Function.c Function.h
  group code/Get_time
    ../../code/Get_time/: Get_time.c Get_time.h
  group code/Motor_Control
    ../../code/Motor_Control/: Motor_Control.c Motor_Control.h
  group code/Motor_Control/Foc
    ../../code/Motor_Control/Foc/: Foc_Loop.c Foc_Loop.h
  group code/Motor_Control/Observer
    ../../code/Motor_Control/Observer/: PLL.c PLL.h SMO.c SMO.h HFI.c HFI.h
  group code/Motor_Control/Feedback
    ../../code/Motor_Control/Feedback/: Encoder_Feedback.c Encoder_Feedback.h
  group code/Motor_Control/Startup
    ../../code/Motor_Control/Startup/: Open_Loop.c Open_Loop.h Zero_Calibration.c Zero_Calibration.h
  group code/Motor_Flash
    ../../code/Motor_Flash/: Motor_Flash.c Motor_Flash.h
  group code/Motor_Torque
    ../../code/Motor_Torque/: Motor_Torque.c Motor_Torque.h
  group code/My_ADC
    ../../code/My_ADC/: My_ADC.c My_ADC.h
  group code/My_Key
    ../../code/My_Key/: My_Key.c My_Key.h
  group code/My_LED
    ../../code/My_LED/: My_LED.c My_LED.h
  group code/My_TCPWM
    ../../code/My_TCPWM/: My_TCPWM.c My_TCPWM.h
  group code/PID
    ../../code/PID/: PID.c PID.h
  group code/SVPWM
    ../../code/SVPWM/: SVPWM.c SVPWM.h
  group doc
    ../../../libraries/doc/: GPL3_permission_statement.txt version.txt
  group sdk/hdr
    ../../../libraries/sdk/common/hdr/: cy_project.h
  group sdk/hdr/cmsis/dsp
    ../../../libraries/sdk/common/hdr/cmsis/dsp/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h
  group sdk/hdr/cmsis/include
    ../../../libraries/sdk/common/hdr/cmsis/include/: cachel1_armv7.h cmsis_compiler.h core_cm0plus.h
  group sdk/hdr/rev_b
    ../../../libraries/sdk/tviibh4m/hdr/: bb_bsp_tviibh4m.h bb_bsp_tviibh4m_revb.h cy_device_headers.h cyt2bl_config.h
  group sdk/hdr/rev_b/ip
    ../../../libraries/sdk/tviibh4m/hdr/ip/: cyip_backup_v3.h cyip_canfd.h cyip_coredefines.h cyip_cpuss.h cyip_crypto.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth_v2.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_gpio_v3.h cyip_headers.h cyip_hsiom_v3.h cyip_i2s_v2.h cyip_ipc.h cyip_lin.h cyip_pass.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_scb_v2.h cyip_sdhc.h cyip_sflash_v2.h cyip_smartio_v3.h cyip_smif_v2.h cyip_srss_v3.h cyip_tcpwm_v2.h
  group sdk/src/drivers/adc
    ../../../libraries/sdk/common/src/drivers/adc/: cy_adc.c cy_adc.h
  group sdk/src/drivers/canfd
    ../../../libraries/sdk/common/src/drivers/canfd/: cy_canfd.c cy_canfd.h
  group sdk/src/drivers/cpu
    ../../../libraries/sdk/tviibh4m/src/drivers/cpu/: cy_cpu.c cy_cpu.h
  group sdk/src/drivers/crypto
    ../../../libraries/sdk/common/src/drivers/crypto/: cy_crypto.h cy_crypto_common.h cy_crypto_config.c cy_crypto_config.h cy_crypto_server.h
  group sdk/src/drivers/dma
    ../../../libraries/sdk/common/src/drivers/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group sdk/src/drivers/evtgen
    ../../../libraries/sdk/common/src/drivers/evtgen/: cy_evtgen.c cy_evtgen.h
  group sdk/src/drivers/flash
    ../../../libraries/sdk/common/src/drivers/flash/: cy_flash.c cy_flash.h
  group sdk/src/drivers/gpio
    ../../../libraries/sdk/common/src/drivers/gpio/: cy_gpio.c cy_gpio.h
  group sdk/src/drivers/ipc
    ../../../libraries/sdk/common/src/drivers/ipc/: cy_ipc_config.h cy_ipc_drv.c cy_ipc_drv.h cy_ipc_pipe.c cy_ipc_pipe.h cy_ipc_sema.c cy_ipc_sema.h
  group sdk/src/drivers/lin
    ../../../libraries/sdk/common/src/drivers/lin/: cy_lin.c cy_lin.h
  group sdk/src/drivers/lvd
    ../../../libraries/sdk/common/src/drivers/lvd/: cy_lvd.c cy_lvd.h
  group sdk/src/drivers/mcwdt
    ../../../libraries/sdk/common/src/drivers/mcwdt/: cy_mcwdt.c cy_mcwdt.h
  group sdk/src/drivers/mpu
    ../../../libraries/sdk/common/src/drivers/mpu/: cy_mpu.c cy_mpu.h
  group sdk/src/drivers/prot
    ../../../libraries/sdk/common/src/drivers/prot/: cy_prot.c cy_prot.h
  group sdk/src/drivers/scb
    ../../../libraries/sdk/common/src/drivers/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group sdk/src/drivers/smartio
    ../../../libraries/sdk/common/src/drivers/smartio/: cy_smartio.c cy_smartio.h
  group sdk/src/drivers/smif
    ../../../libraries/sdk/common/src/drivers/smif/common/: cy_smif.c cy_smif.h cy_smif_memslot.c cy_smif_memslot.h
    ../../../libraries/sdk/common/src/drivers/smif/ver2/: cy_smif_ver_specific.c cy_smif_ver_specific.h
  group sdk/src/drivers/srom
    ../../../libraries/sdk/common/src/drivers/srom/: cy_srom.c cy_srom.h
  group sdk/src/drivers/sysclk
    ../../../libraries/sdk/tviibh4m/src/drivers/sysclk/: cy_sysclk.c cy_sysclk.h
  group sdk/src/drivers/sysflt
    ../../../libraries/sdk/common/src/drivers/sysflt/: cy_sysflt.c cy_sysflt.h
    ../../../libraries/sdk/tviibh4m/src/drivers/sysflt/: cy_sysflt_config.h
  group sdk/src/drivers/sysint
    ../../../libraries/sdk/common/src/drivers/sysint/: cy_sysint.c cy_sysint.h
  group sdk/src/drivers/syslib
    ../../../libraries/sdk/common/src/drivers/syslib/: cy_syslib.c cy_syslib.h
    ../../../libraries/sdk/common/src/drivers/syslib/iar/: cy_syslib_iar.s
  group sdk/src/drivers/syspm
    ../../../libraries/sdk/common/src/drivers/syspm/: cy_syspm.c cy_syspm.h
  group sdk/src/drivers/sysreset
    ../../../libraries/sdk/common/src/drivers/sysreset/: cy_sysreset.c cy_sysreset.h
  group sdk/src/drivers/sysrtc
    ../../../libraries/sdk/common/src/drivers/sysrtc/: cy_sysrtc.c cy_sysrtc.h
  group sdk/src/drivers/systick
    ../../../libraries/sdk/common/src/drivers/systick/: cy_systick.c cy_systick.h
  group sdk/src/drivers/syswdt
    ../../../libraries/sdk/common/src/drivers/syswdt/: cy_syswdt.c cy_syswdt.h
  group sdk/src/drivers/tcpwm
    ../../../libraries/sdk/common/src/drivers/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group sdk/src/drivers/trigmux
    ../../../libraries/sdk/common/src/drivers/trigmux/: cy_trigmux.c cy_trigmux.h
  group sdk/src/interrupts/rev_b
    ../../../libraries/sdk/tviibh4m/src/interrupts/: cy_interrupt_map.c cy_interrupt_map_cm4.h
  group sdk/src/mw/button
    ../../../libraries/sdk/common/src/mw/button/: cy_button.c cy_button.h
  group sdk/src/mw/flash
    ../../../libraries/sdk/common/src/mw/flash/: cy_mw_flash.c cy_mw_flash.h
  group sdk/src/mw/semihosting
    ../../../libraries/sdk/common/src/mw/semihosting/: cy_semihosting.c cy_semihosting.h
  group sdk/src/mw/sw_timer
    ../../../libraries/sdk/common/src/mw/sw_timer/: cy_sw_tmr.c cy_sw_tmr.h
  group sdk/src/startup
    ../../../libraries/sdk/common/src/startup/: startup.c startup_customize.h
    ../../../libraries/sdk/common/src/startup/iar/: startup_cm4.s
  group sdk/src/system/rev_b
    ../../../libraries/sdk/tviibh4m/src/system/: system_cyt2bl.h system_tviibe4m_cm4.c
  group user
    ../../user/: cm4_isr.c main_cm4.c
  group zf_common
    ../../../libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_headfile.h zf_common_interrupt.c zf_common_interrupt.h zf_common_typedef.h
  group zf_components
    ../../../libraries/zf_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_interface.c seekfree_assistant_interface.h
  group zf_device
    ../../../libraries/zf_device/: zf_device_ble6a20.c zf_device_ble6a20.h zf_device_config.h zf_device_dl1a.c zf_device_dl1a.h zf_device_dl1b.c zf_device_dl1b.h zf_device_gnss.c zf_device_gnss.h zf_device_icm20602.c zf_device_icm20602.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu660rb.c zf_device_imu660rb.h zf_device_imu660rc.c zf_device_imu660rc.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_ips200pro.c zf_device_ips200pro.h zf_device_key.c zf_device_key.h zf_device_menc15a.c zf_device_menc15a.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_oled.c zf_device_oled.h zf_device_tft180.c zf_device_tft180.h zf_device_tsl1401.c zf_device_tsl1401.h zf_device_type.c zf_device_type.h zf_device_uart_receiver.c zf_device_uart_receiver.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h 外设文件说明.txt
  group zf_driver
    ../../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_delay.c zf_driver_delay.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_flash.c zf_driver_flash.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_soft_spi.c zf_driver_soft_spi.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h
